## defconfig
```kconfig
CONFIG_EAP_GTC=y
CONFIG_EAP_MSCHAPV2=y
CONFIG_EAP_TLS=y
CONFIG_EAP_PEAP=y
CONFIG_EAP_TTLS=y
CONFIG_EAP_LEAP=y
CONFIG_BACKEND=file
CONFIG_EAPOL_TEST=y
CONFIG_IPV6=y
```
